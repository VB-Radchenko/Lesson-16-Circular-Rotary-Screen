# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\Build.bat
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_M5.A51 Main.c sys.c UART_xx.c RTC_51.c encoder.c
